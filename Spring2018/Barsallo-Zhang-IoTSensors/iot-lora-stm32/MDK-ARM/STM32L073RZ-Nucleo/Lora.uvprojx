# Keil uVision project Lora.uvprojx, settings and files
target sx1276mb1mas (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER, USE_BAND_868,USE_MODEM_LORA
  c misc: --C99
  c include: ..\..\inc;..\..\sdk_drivers\BSP\STM32L0xx_Nucleo;..\..\sdk_drivers\STM32L0xx_HAL_Driver\Inc;..\..\sdk_drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\sdk_drivers\CMSIS\Include;..\..\sdk_middlewares\Third_Party\Lora\Crypto;..\..\sdk_middlewares\Third_Party\Lora\Mac;..\..\sdk_middlewares\Third_Party\Lora\Phy;..\..\sdk_middlewares\Third_Party\Lora\Utilities;..\..\sdk_drivers\BSP\X_NUCLEO_IKS01A1;..\..\sdk_drivers\BSP\Components\Common;..\..\sdk_drivers\BSP\Components\hts221;..\..\sdk_drivers\BSP\Components\lps25hb;..\..\sdk_drivers\BSP\Components\sx1276;..\..\sdk_middlewares\Third_Party\Lora\Core;..\..\sdk_drivers\BSP\sx1276mb1mas
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../sdk_drivers/BSP/Components/sx1272/: sx1272.c
    ../../sdk_drivers/BSP/Components/sx1276/: sx1276.c
    ../../src/: i2c_dr.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../sdk_drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/sx1272mb2das
    ../../sdk_drivers/BSP/sx1272mb2das/: sx1272mb2das.c
  group Drivers/BSP/sx1276mb1mas
    ../../sdk_drivers/BSP/sx1276mb1mas/: sx1276mb1mas.c
  group Drivers/BSP/sx1276mb1las
    ../../sdk_drivers/BSP/sx1276mb1las/: sx1276mb1las.c
  group Drivers/BSP/LRWAN_NS1
    ../../sdk_drivers/BSP/LRWAN_NS1/: sx1276_lrwan_ns1.c
  group Drivers/CMSIS
    ../../sdk_drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../sdk_drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c
  group Projects/MDK-ARM
    ./: startup_stm32l073xx.s
  group Projects/PingPong
    ../../src/: debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c stm32l0xx_hal_msp.c stm32l0xx_hw.c stm32l0xx_it.c vcom.c demo.c mesh.c
  group Middlewares/Lora/Utilities
    ../../sdk_middlewares/Third_Party/Lora/Utilities/: delay.c low_power.c timeServer.c utilities.c
target sx1272mb2das (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_STM32L0XX_NUCLEO, USE_HAL_DRIVER, USE_BAND_915,USE_MODEM_LORA, __CC_ARM
  c misc: --C99
  c include: ..\..\inc;..\..\sdk_drivers\BSP\STM32L0xx_Nucleo;..\..\sdk_drivers\STM32L0xx_HAL_Driver\Inc;..\..\sdk_drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\sdk_drivers\CMSIS\Include;..\..\sdk_middlewares\Third_Party\Lora\Crypto;..\..\sdk_middlewares\Third_Party\Lora\Mac;..\..\sdk_middlewares\Third_Party\Lora\Phy;..\..\sdk_middlewares\Third_Party\Lora\Utilities;..\..\sdk_drivers\BSP\X_NUCLEO_IKS01A1;..\..\sdk_drivers\BSP\Components\Common;..\..\sdk_drivers\BSP\Components\hts221;..\..\sdk_drivers\BSP\Components\lps25hb;..\..\sdk_drivers\BSP\Components\sx1272;..\..\sdk_middlewares\Third_Party\Lora\Core;..\..\sdk_drivers\BSP\sx1272mb2das;..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target sx1276mb1las (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER, USE_BAND_868, USE_MODEM_LORA
  c misc: --C99
  c include: ..\..\inc;..\..\sdk_drivers\BSP\STM32L0xx_Nucleo;..\..\sdk_drivers\STM32L0xx_HAL_Driver\Inc;..\..\sdk_drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\sdk_drivers\CMSIS\Include;..\..\sdk_middlewares\Third_Party\Lora\Crypto;..\..\sdk_middlewares\Third_Party\Lora\Mac;..\..\sdk_middlewares\Third_Party\Lora\Phy;..\..\sdk_middlewares\Third_Party\Lora\Utilities;..\..\sdk_drivers\BSP\X_NUCLEO_IKS01A1;..\..\sdk_drivers\BSP\Components\Common;..\..\sdk_drivers\BSP\Components\hts221;..\..\sdk_drivers\BSP\Components\lps25hb;..\..\sdk_drivers\BSP\Components\sx1276;..\..\sdk_middlewares\Third_Party\Lora\Core;..\..\sdk_drivers\BSP\sx1276mb1las
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target LRWAN-NS1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: ..\..\inc;..\..\sdk_drivers\BSP\STM32L0xx_Nucleo;..\..\sdk_drivers\STM32L0xx_HAL_Driver\Inc;..\..\sdk_drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\sdk_drivers\CMSIS\Include;..\..\sdk_middlewares\Third_Party\Lora\Crypto;..\..\sdk_middlewares\Third_Party\Lora\Mac;..\..\sdk_middlewares\Third_Party\Lora\Phy;..\..\sdk_middlewares\Third_Party\Lora\Utilities;..\..\sdk_drivers\BSP\X_NUCLEO_IKS01A1;..\..\sdk_drivers\BSP\Components\Common;..\..\sdk_drivers\BSP\Components\hts221;..\..\sdk_drivers\BSP\Components\lps25hb;..\..\sdk_drivers\BSP\Components\sx1276;..\..\sdk_middlewares\Third_Party\Lora\Core;..\..\sdk_drivers\BSP\LRWAN_NS1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
