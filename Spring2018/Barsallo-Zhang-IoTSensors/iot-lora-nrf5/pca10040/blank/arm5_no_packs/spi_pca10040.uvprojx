# Keil uVision project spi_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_BAND_915, USE_MODEM_LORA DEBUG BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\sdk_components;..\..\..\sdk_components\boards;..\..\..\sdk_components\drivers_nrf\common;..\..\..\sdk_components\drivers_nrf\delay;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\nrf_soc_nosd;..\..\..\sdk_components\drivers_nrf\spi_master;..\..\..\sdk_components\drivers_nrf\uart;..\..\..\sdk_components\libraries\atomic;..\..\..\sdk_components\libraries\balloc;..\..\..\sdk_components\libraries\bsp;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\libraries\experimental_log;..\..\..\sdk_components\libraries\experimental_log\src;..\..\..\sdk_components\libraries\experimental_memobj;..\..\..\sdk_components\libraries\experimental_section_vars;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\strerror;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\toolchain;..\..\..;..\..\..\sdk_external\fprintf;..\..\..\sdk_external\segger_rtt;..\config;..\..\..\sdk_components\drivers_nrf\timer;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\twi_master
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\sdk_components;..\..\..\sdk_components\boards;..\..\..\sdk_components\drivers_nrf\common;..\..\..\sdk_components\drivers_nrf\delay;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\nrf_soc_nosd;..\..\..\sdk_components\drivers_nrf\spi_master;..\..\..\sdk_components\drivers_nrf\uart;..\..\..\sdk_components\libraries\atomic;..\..\..\sdk_components\libraries\balloc;..\..\..\sdk_components\libraries\bsp;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\libraries\experimental_log;..\..\..\sdk_components\libraries\experimental_log\src;..\..\..\sdk_components\libraries\experimental_memobj;..\..\..\sdk_components\libraries\experimental_section_vars;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\strerror;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\toolchain;..\..\..;..\..\..\sdk_external\fprintf;..\..\..\sdk_external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c sx1272.c hw_gpio.c hw_spi.c timeServer.c sx1272mb2das.c utilities.c mesh.c demo.c i2c_dr.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../sdk_components/boards/: boards.c
  group Board Support
    ../../../sdk_components/libraries/bsp/: bsp.c bsp_nfc.c
  group nRF_Drivers
    ../../../sdk_components/drivers_nrf/common/: nrf_drv_common.c
    ../../../sdk_components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../sdk_components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../sdk_components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../sdk_components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../sdk_components/drivers_nrf/twi_master/: nrf_drv_twi.c
  group nRF_Libraries
    ../../../sdk_components/libraries/button/: app_button.c
    ../../../sdk_components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../sdk_components/libraries/scheduler/: app_scheduler.c
    ../../../sdk_components/libraries/timer/: app_timer.c
    ../../../sdk_components/libraries/balloc/: nrf_balloc.c
    ../../../sdk_external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../sdk_components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../sdk_components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../sdk_components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../sdk_external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
